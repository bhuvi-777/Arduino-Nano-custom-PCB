# Repository bhuvi-777/Arduino-Nano-custom-PCB

File README.md:

# Arduino Nano - Custom PCB Design (KiCad)

This repository contains the **custom PCB design of an Arduino Nano**, fully developed in **KiCad**. The design replicates the Arduino Nano form factor and functionality with customized routing and layout optimization.

## 📂 Contents

- KiCad Project Files (`.kicad_pro`, `.kicad_sch`, `.kicad_pcb`)
- Schematics and PCB Layout
- Gerber and Drill files (for fabrication)
- 3D Render Images of the PCB
- Netlist and footprint cache

## 🛠 Tools Used

- **KiCad**: Schematic & PCB Design
- **KiCad 3D Viewer**: Visualization
- **Gerber Viewer**: File validation for manufacturing

## 📸 Preview

### Schematic

### PCB Layout

### 3D View

## 🏭 Fabrication
You can directly use the **Gerber files** in the `Gerber/` folder for PCB manufacturing via services like:
- JLCPCB
- PCBWay
- Seeed Fusion

## 📜 License
This project is licensed under the **MIT License** — see the [LICENSE](LICENSE) file for details.

## 🤝 Contributions
Contributions, improvements, or feedback are welcome. Feel free to fork the repository or raise an issue!

---

*Happy Building!*

## KiCad design Arduino Nano Custom PCB/PCB_Layout/Arduino nano.kicad_pcb

File Arduino Nano Custom PCB/README.md:

# Arduino Nano - Custom PCB Design (KiCad)

This repository contains the **custom PCB design of an Arduino Nano**, fully developed in **KiCad**. The design replicates the Arduino Nano form factor and functionality with customized routing and layout optimization.

## 📂 Contents

- KiCad Project Files (`.kicad_pro`, `.kicad_sch`, `.kicad_pcb`)
- Schematics and PCB Layout
- Gerber and Drill files (for fabrication)
- 3D Render Images of the PCB
- Netlist and footprint cache

## 🛠 Tools Used

- **KiCad**: Schematic & PCB Design
- **KiCad 3D Viewer**: Visualization
- **Gerber Viewer**: File validation for manufacturing

## 📸 Preview

### Schematic

### PCB Layout

### 3D View

## 🏭 Fabrication
You can directly use the **Gerber files** in the `Gerber/` folder for PCB manufacturing via services like:
- JLCPCB
- PCBWay
- Seeed Fusion

## 📜 License
This project is licensed under the **MIT License** — see the [LICENSE](LICENSE) file for details.

## 🤝 Contributions
Contributions, improvements, or feedback are welcome. Feel free to fork the repository or raise an issue!

---

*Happy Building!*

Parts:
C1, C2, C5, C6: 1u; C_0603_1608Metric
C3, C7, C8, C10: 100n; C_0603_1608Metric
C4, C9: 4u7_16V; CP_EIA-3216-10_Kemet-I
D1: Yellow; LED_0805_2012Metric
D2, D5: Green; LED_0805_2012Metric
D3: Diode; D_MicroSMP_AK
D4: Red; LED_0805_2012Metric
F1: 0603; D_0603_1608Metric
J1: USB_B_Mini; USB_Mini-B_Wuerth_65100516121_Horizontal
J2, J4: Conn_01x15_Pin; PinSocket_1x15_P2.54mm_Vertical
J3: ICSP; PinHeader_1x03_P2.54mm_Vertical
J5: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7: 1k; D_0603_1608Metric
SW1: SW_Push; Panasonic_EVQPUK_EVQPUB
TP1, TP2: TestPoint_Small; TestPoint_Pad_D1.0mm
U1: ATmega328-M; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm
U2: LM1117MP-5.0; SOT-223-3_TabPin2
U3: FT232RL; SSOP-28_5.3x10.2mm_P0.65mm
Y1: 16MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3.3V: C7.1, J2.14, U3.17 (3V3OUT)
+5V: C1.1, C2.1, C4.1, C6.1, D3.1 (K), D4.2 (A), D5.2 (A), J2.4, J3.1, R1.1, R5.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U2.2 (VO), U3.4 (VCCIO), U3.20 (VCC)
/A0: J2.12, U1.23 (PC0)
/A1: J2.11, U1.24 (PC1)
/A2: J2.10, U1.25 (PC2)
/A3: J2.9, U1.26 (PC3)
/A4: J2.8, U1.27 (PC4)
/A5: J2.7, U1.28 (PC5)
/A6: J2.6, U1.19 (ADC6)
/A7: J2.5, U1.22 (ADC7)
/AREF: C3.1, J2.13, U1.20 (AREF)
/D0/RX: J4.1, R2.1, U1.30 (PD0)
/D1/TX: J4.2, R3.1, U1.31 (PD1)
/D2: J4.5, U1.32 (PD2)
/D3: J4.6, U1.1 (PD3)
/D4: J4.7, U1.2 (PD4)
/D5: J4.8, U1.9 (PD5)
/D6: J4.9, U1.10 (PD6)
/D7: J4.10, U1.11 (PD7)
/D8: J4.11, U1.12 (PB0)
/D9: J4.12, U1.13 (PB1)
/D10: J4.13, U1.14 (PB2)
/D11/MOSI: J3.2, J4.14, U1.15 (PB3)
/D12/MISO: J4.15, J5.1, U1.16 (PB4)
/D13/SCK: J2.15, J5.2, R4.1, U1.17 (PB5)
/D_N: J1.2 (D-), TP2.1, U3.16 (USBD-)
/D_P: J1.3 (D+), TP1.1, U3.15 (USBD+)
/RESET: C8.1, J2.2, J4.3, J5.3, R1.2, SW1.1, U1.29 (~RESET/PC6)
/RX: R2.2, U3.1 (TXD)
/TX: R3.2, U3.5 (RXD)
/XTAL1: U1.7 (XTAL1/PB6), Y1.3
/XTAL2: U1.8 (XTAL2/PB7), Y1.1
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C9.2, C10.2, D1.1 (K), D2.1 (K), J1.5 (GND), J1.6 (Shield), J2.3, J3.3, J4.4, SW1.2, U1.3 (GND), U1.5 (GND), U1.21 (GND), U1.33 (GND), U2.1 (GND), U3.7 (GND), U3.18 (GND), U3.21 (GND), U3.25 (AGND), U3.26 (TEST), Y1.2
unnamed: D1.2 (A), R4.2
unnamed: D2.2 (A), R5.2
unnamed: D4.1 (K), R6.1
unnamed: D5.1 (K), R7.1
unnamed: F1.2, J1.1 (VBUS)
unnamed: R6.2, U3.23 (CBUS0)
unnamed: R7.2, U3.22 (CBUS1)
unnamed: C8.2, U3.3 (RTS)
VBUS: C9.1, C10.1, D3.2 (A), F1.1
VCC: C5.2, J2.1, U2.3 (VI)

Notes on the sheet:
ATMEGA Microcontroller
PIN HEADERS
POWER
USB INTERFACE

Board: 4 copper layers, 47.5 x 22.0 mm, 35 parts (16 on the bottom side), 43 nets.

## Commit log

2025-07-20 Create LICENSE
